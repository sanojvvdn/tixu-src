FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-u-boot-board-support.patch \
	    file://0002-u-boot-SD-card-boot.patch \
		"	

